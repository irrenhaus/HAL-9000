**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*             Version 0.9.99 Alpha (16/04/2010)              *
**************************************************************

* Component Definitions
C301 45 0 100nF
C302 52 51 100nF
C303 0 38 100nF
C304 0 45 100nF
C305 45 0 100nF
C306 0 45 100nF
C307 45 0 100nF
C401 45 0 100nF
C501 52 0 10uF
C502 52 0 100nF
C503 26 0 10uF
C701 0 13 0.3uF
C702 0 12 100nF
C703 0 8 100nF
C704 51 11 100nF
C705 51 10 100nF
C706 51 9 100nF
C707 51 17 100nF
C708 51 14 100nF
D301 66 62 Red
D501 0 26 20V
F501 56 26 5A Fuse
J401 0 26 59 58 5 24 6 4 0 RJ45
K301 63 72 65 EXPA
L501 51 0 100Ohm
L502 52 45 10uH
Q301 0 67 62 NPN
R301 45 66 100
R302 45 68 100k
R303 0 73 100k
R304 38 45 100k
R305 67 45 100k
R401 58 59 120
R501 55 0 360
R502 45 55 220
R701 12 45 10k
R702 0 8 4k7
R703 45 13 2k7
R704 0 8 2k7
R705 51 11 2k7
R706 51 10 2k7
R707 51 9 2k7
R708 51 17 2k7
R709 54 13 10k
R710 50 12 120
R711 53 8 10k
R712 46 11 10k
R713 49 10 10k
R714 47 9 10k
R715 48 17 10k
R716 45 35 4k7
R717 45 36 4k7
R718 51 14 2k7
R719 26 14 10k
XU301 81 21 45 0 22 20 68 45 AT25DF041A
XU302 83 75 76 77 74 82 38 15 16 7 18 51 52 69 61 70 64 0 45 71 20 21 22 8 12 43 33 81 28 27 0 45 5 24 4 6 13 29 23 31 19 42 41 30 25 37 0 45 40 39 32 34 1 78 2 3 35 36 67 73 79 80 0 45 STM32F103R8
XU303 45 0 74 45 8MHz
XU304 71 61 51 17 11 10 9 69 65 72 63 14 52 0 70 64 DG408DYZ
XU401 25 0 45 30 60 58 59 57 SN65HVD232
XU501 26 55 45 LM317
XU701 0 45 12 BAS40-04
XU702 0 45 13 BAS40-04
XU703 0 45 8 BAS40-04
XU704 51 52 11 BAS40-04
XU705 51 52 10 BAS40-04
XU706 51 52 9 BAS40-04
XU707 51 52 17 BAS40-04
XU708 0 35 45 DS1820
XU709 0 36 45 DS1820
XU710 51 52 14 BAS40-04

* NG-Spice Simulation Commands
.OPTIONS NOPAGE NUMDGT=6 UNITS=Degress WIDTH=104
.PRINT DC V(51,11) V(70)
.DC TEMP 20.00 30.00 1.00

.END
